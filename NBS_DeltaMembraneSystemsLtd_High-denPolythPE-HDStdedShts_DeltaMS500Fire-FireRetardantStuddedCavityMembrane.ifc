Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:04:32
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane, Basic Wall:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane:222055
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane 8 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_51_36: High-density polyethylene (PE-HD) studded sheets; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Type C fire-retardant 8 mm studded HDPE cavity drainage membrane; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta MS 500 Fire - Fire Retardant Studded Cavity Membrane; Name: High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/8c7126d1-afdb-4f07-9ac8-e4966dd43e7d/6a6a753e-c1ab-4139-82fd-f7b35ed57567; Uniclass2015Code: Pr_25_57_51_36; Uniclass2015Title: High-density polyethylene (PE-HD) studded sheets; Uniclass2015Version: Products v1.35; Version: 9
Type - NBS_Data - Standard: Type C Drained Protection in accordance with BS 8102:2009; StudHeight: 8 mm; SheetThickness: 0.5 mm; Colour: White; PerformanceCharacteristicsFlowRate: 2.25 L/s/m; PerformanceCharacteristicsFirePerformance: To EN 13501-1:2018 Class B-s2, d0; RecycledContent: 0; ContainsRedListMaterials: No; CountryOfProductManufacture: Germany; Material: High density polyethylene (HDPE); Recyclability: Yes; RollSize: 20 x 2.4 m; TypicalCompressiveStrength: >250 kN/m²; ServiceTemperatureRange: -30°C to +80°C
Classification: Pr_25_57_51_36 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane, Floor:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane:221899
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane 8 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_51_36: High-density polyethylene (PE-HD) studded sheets; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Type C fire-retardant 8 mm studded HDPE cavity drainage membrane; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta MS 500 Fire - Fire Retardant Studded Cavity Membrane; Name: High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaMS500Fire-FireRetardantStuddedCavityMembrane; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/8c7126d1-afdb-4f07-9ac8-e4966dd43e7d/10c47523-12bd-4f31-9ec0-92473ffeacf2; Uniclass2015Code: Pr_25_57_51_36; Uniclass2015Title: High-density polyethylene (PE-HD) studded sheets; Uniclass2015Version: Products v1.35; Version: 8
Type - NBS_Data - Standard: Type C Drained Protection in accordance with BS 8102:2009; StudHeight: 8 mm; SheetThickness: 0.5 mm; Colour: White; PerformanceCharacteristicsFlowRate: 2.25 L/s/m; PerformanceCharacteristicsFirePerformance: To EN 13501-1:2018 Class B-s2, d0; RecycledContent: 0; ContainsRedListMaterials: No; CountryOfProductManufacture: Germany; Material: High density polyethylene (HDPE); Recyclability: Yes; RollSize: 20 x 2.4 m; TypicalCompressiveStrength: >250 kN/m²; ServiceTemperatureRange: -30°C to +80°C
Classification: Pr_25_57_51_36 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
